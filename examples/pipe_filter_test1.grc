options:
  parameters:
    author: Julien Olivain <juju@cotds.org>
    category: Custom
    generate_options: qt_gui
    id: pipe_filter_test1
    output_language: python
    run_options: run
    title: Pipe Filter Test 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.2'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: pipe_filter_0
  id: pipe_filter
  parameters:
    command: cat
    comment: |-
      Replace the 'cat' command with any program processing samples.
      (sample programs are in the "examples/square_pipe_blocks" directory)
    in_type: float
    in_vlen: '1'
    out_type: float
    out_vlen: '1'
    rel_rate: '1.0'
    unbuffered: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Output
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', pipe_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [pipe_filter_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
