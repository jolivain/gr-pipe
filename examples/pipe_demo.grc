options:
  parameters:
    author: Julien Olivain <juju@cotds.org>
    generate_options: no_gui
    id: pipe_demo
    output_language: python
    title: Pipe blocks demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '256'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: pipe_filter_0
  id: pipe_filter
  parameters:
    command: tr a-z A-Z
    comment: |-
      Filter uses the 'tr' command to replace
      lower case character to upper case.
    in_type: byte
    in_vlen: '1'
    out_type: byte
    out_vlen: '1'
    rel_rate: '1.0'
    unbuffered: 'False'
  states: {}
- name: pipe_sink_0
  id: pipe_sink
  parameters:
    command: cat > /tmp/output.txt
    comment: |-
      Sink uses the 'cat' command and
      shell redirection as a file sink.
    in_type: byte
    in_vlen: '1'
    unbuffered: 'False'
  states: {}
- name: pipe_source_0
  id: pipe_source
  parameters:
    command: while true ; do echo "hello gnu radio $RANDOM" ; done
    comment: |-
      Source uses a shell loop to print 'hello gnuradio'
      in lower case and a random number.
    out_type: byte
    out_vlen: '1'
  states: {}

connections:
- [blocks_head_0, '0', pipe_sink_0, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [pipe_filter_0, '0', blocks_throttle_0, '0']
- [pipe_source_0, '0', pipe_filter_0, '0']

metadata:
  file_format: 1
