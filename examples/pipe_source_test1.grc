options:
  parameters:
    author: Julien Olivain <juju@cotds.org>
    category: Custom
    generate_options: qt_gui
    id: pipe_source_test1
    output_language: python
    title: Pipe Source Test 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: 2**31
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: pipe_source_0_0
  id: pipe_source
  parameters:
    command: cat /dev/urandom
    comment: Pipe Source used as a file source.
    out_type: int
    out_vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_int_to_float_0, '0']
- [pipe_source_0_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
