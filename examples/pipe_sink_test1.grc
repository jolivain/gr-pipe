options:
  parameters:
    author: Julien Olivain <juju@cotds.org>
    category: Custom
    generate_options: no_gui
    id: pipe_sink_test1
    output_language: python
    title: Pipe Sink Test 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: Limit to a fixed number of sample, to prevent console flooding.
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pipe_sink_0_0
  id: pipe_sink
  parameters:
    command: od -tf4 -w8 -v
    comment: Print raw sample values on console with the 'od' command.
    in_type: complex
    in_vlen: '1'
    unbuffered: 'False'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', pipe_sink_0_0, '0']

metadata:
  file_format: 1
