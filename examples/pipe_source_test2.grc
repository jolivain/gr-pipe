options:
  parameters:
    author: Julien Olivain <juju@cotds.org>
    category: Custom
    generate_options: qt_gui
    id: pipe_source_test2
    output_language: python
    title: Pipe Source Test 2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/256.
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: pipe_source_0_0
  id: pipe_source
  parameters:
    command: while true ; do echo Hello GNU Radio $RANDOM ! ; done
    comment: Generate sample from shell script.
    out_type: byte
    out_vlen: '1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [pipe_source_0_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
