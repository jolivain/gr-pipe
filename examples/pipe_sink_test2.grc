<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>pipe_sink</key>
<param><key>id</key><value>pipe_sink_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>in_vlen</key><value>1</value></param>
<param><key>command</key><value>hexdump -Cv</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>num_samps</key><value>65</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>pipe_sink_test2</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>pipe_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
