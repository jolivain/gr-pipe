options:
  parameters:
    author: Julien Olivain <juju@cotds.org>
    category: Custom
    generate_options: no_gui
    id: pipe_sink_test2
    output_language: python
    title: Pipe SInk Test 2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: Limit to a fixed number of sample, to prevent console flooding.
    num_items: '1024'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: pipe_sink_0
  id: pipe_sink
  parameters:
    command: hexdump -Cv
    in_type: byte
    in_vlen: '1'
    unbuffered: 'False'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', pipe_sink_0, '0']

metadata:
  file_format: 1
